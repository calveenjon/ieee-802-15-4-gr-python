options:
  parameters:
    author: Calveen Jon Elvin
    generate_options: qt_gui
    id: wsn_testbench_ml_inference
    output_language: python
    title: WSN Test Bench ML Interference
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: '45'
  states: {}
- name: oversample
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rrc_rx
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, excess_bw, ntaps)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,samp_rate,samp_rate/sps,excess_bw,11*sps)
  states: {}
- name: rrc_tx
  id: variable
  parameters:
    value: firdes.root_raised_cosine(sps, sps, 1, excess_bw, sps*ntaps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_constellation_rect_0
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707-0.707j, 0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.001'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/user/spectrum_dataset_complex64_iq/wifi_stream_4MHz.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-0.707-0.707j, -0.707+0.707j, 0.707-0.707j, 0.707+0.707j]'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_rect_0
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.0628'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: '0.0628'
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_rx
    type: ccc
  states: {}
- name: ieee_802_15_4_python_bits_to_chips_mapper_0
  id: ieee_802_15_4_python_bits_to_chips_mapper
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_channel_mux_0
  id: ieee_802_15_4_python_channel_mux
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_chips_to_bits_mapper_0
  id: ieee_802_15_4_python_chips_to_bits_mapper
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_csma_ca_0
  id: ieee_802_15_4_python_csma_ca
  parameters:
    ml_data_scaler: /home/user/rf_ml_classifier/proposed_method/spectrum_energy_dataset_100k_samples/model/rf_features_dataset_16.csv_scaler.pickle
    rf_classifier_path: /home/user/rf_ml_classifier/proposed_method/spectrum_energy_dataset_100k_samples/model/rf_features_dataset_16.csv_model.pickle
    sampling_window_size: '16'
  states: {}
- name: ieee_802_15_4_python_mac_frame_pack_0
  id: ieee_802_15_4_python_mac_frame_pack
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_mac_frame_unpack_0
  id: ieee_802_15_4_python_mac_frame_unpack
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_phy_frame_pack_0
  id: ieee_802_15_4_python_phy_frame_pack
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_phy_frame_unpack_0
  id: ieee_802_15_4_python_phy_frame_unpack
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_transmit_mux_0
  id: ieee_802_15_4_python_transmit_mux
  parameters: {}
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    taps: rrc_tx
    type: ccc
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '100'
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'False'
    type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: '1'
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '1'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_cmd
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: wsn_out
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: wsn_in
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: rf_tx
  states: {}
- name: virtual_sink_1_1_0
  id: virtual_sink
  parameters:
    stream_id: mac_cmd
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: sdr_chan
  states: {}
- name: virtual_sink_2_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rf_rx
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: chan_pow
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: wsn_in
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: wsn_out
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: mac_cmd
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rf_tx
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: rf_tx
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: rf_rx
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: tx_cmd
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: chan_pow
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: sdr_chan
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_const_source_x_0_0, '0', ieee_802_15_4_python_transmit_mux_0, '1']
- [analog_const_source_x_0_1, '0', ieee_802_15_4_python_channel_mux_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', logpwrfft_x_0, '0']
- [blocks_file_source_0, '0', ieee_802_15_4_python_channel_mux_0, '0']
- [blocks_throttle_0, '0', ieee_802_15_4_python_mac_frame_pack_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', ieee_802_15_4_python_phy_frame_unpack_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', virtual_sink_1_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0, '0']
- [fir_filter_xxx_1, '0', digital_symbol_sync_xx_0_0, '0']
- [ieee_802_15_4_python_bits_to_chips_mapper_0, '0', virtual_sink_1, '0']
- [ieee_802_15_4_python_bits_to_chips_mapper_0, tx_mux, virtual_sink_0, '0']
- [ieee_802_15_4_python_channel_mux_0, '0', blocks_add_xx_0, '0']
- [ieee_802_15_4_python_chips_to_bits_mapper_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [ieee_802_15_4_python_csma_ca_0, mpduout, ieee_802_15_4_python_phy_frame_pack_0, mpdu_in]
- [ieee_802_15_4_python_csma_ca_0, sdrcmd, virtual_sink_2, '0']
- [ieee_802_15_4_python_mac_frame_pack_0, mpduout, ieee_802_15_4_python_csma_ca_0, mpduin]
- [ieee_802_15_4_python_mac_frame_unpack_0, '0', blocks_null_sink_0, '0']
- [ieee_802_15_4_python_mac_frame_unpack_0, cmdout, virtual_sink_1_1_0, '0']
- [ieee_802_15_4_python_phy_frame_pack_0, ppdu_out, ieee_802_15_4_python_bits_to_chips_mapper_0, ppdu_in]
- [ieee_802_15_4_python_phy_frame_unpack_0, mpdu, ieee_802_15_4_python_mac_frame_unpack_0, mpduin]
- [ieee_802_15_4_python_transmit_mux_0, '0', virtual_sink_2_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [logpwrfft_x_0, '0', virtual_sink_4, '0']
- [pfb_arb_resampler_xxx_0, '0', virtual_sink_1_1, '0']
- [virtual_source_0, '0', ieee_802_15_4_python_chips_to_bits_mapper_0, '0']
- [virtual_source_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0_1_0, '0', ieee_802_15_4_python_mac_frame_pack_0, cmdin]
- [virtual_source_1, '0', ieee_802_15_4_python_transmit_mux_0, '0']
- [virtual_source_1_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_1_0_0_0, '0', fir_filter_xxx_1, '0']
- [virtual_source_2, '0', ieee_802_15_4_python_transmit_mux_0, tx_cmd]
- [virtual_source_3, '0', ieee_802_15_4_python_csma_ca_0, '0']
- [virtual_source_4, '0', ieee_802_15_4_python_channel_mux_0, chan]

metadata:
  file_format: 1

options:
  parameters:
    author: Calveen Jon Elvin
    generate_options: qt_gui
    id: wsn_testbench_baseline_csma_ca
    output_language: python
    title: WSN Test Bench Baseline CSMA/CA
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.001'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: ieee_802_15_4_python_bits_to_chips_mapper_0
  id: ieee_802_15_4_python_bits_to_chips_mapper
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_chips_to_bits_mapper_1
  id: ieee_802_15_4_python_chips_to_bits_mapper
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_csma_ca_0
  id: ieee_802_15_4_python_csma_ca
  parameters:
    ml_data_scaler: /home/user/gnuradio_mod/rf_classification_ml/proposed_method/spectrum_energy_dataset_100k_samples/model/rf_features_dataset_16.csv_scaler.pickle
    rf_classifier_path: /home/user/gnuradio_mod/rf_classification_ml/proposed_method/spectrum_energy_dataset_100k_samples/model/rf_features_dataset_16.csv_model.pickle
    window_size: '16'
  states: {}
- name: ieee_802_15_4_python_mac_frame_pack_0
  id: ieee_802_15_4_python_mac_frame_pack
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_mac_frame_unpack_0
  id: ieee_802_15_4_python_mac_frame_unpack
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_phy_frame_pack_0
  id: ieee_802_15_4_python_phy_frame_pack
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_phy_frame_unpack_0
  id: ieee_802_15_4_python_phy_frame_unpack
  parameters: {}
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '100'
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'False'
    type: complex
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: wsn_out
  states: {}
- name: virtual_sink_1_1_0
  id: virtual_sink
  parameters:
    stream_id: mac_cmd
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: wsn_in
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: chan_pow
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: wsn_in
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: mac_cmd
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: wsn_out
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: chan_pow
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', logpwrfft_x_0, '0']
- [blocks_throttle_0, '0', ieee_802_15_4_python_mac_frame_pack_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', ieee_802_15_4_python_phy_frame_unpack_0, '0']
- [ieee_802_15_4_python_bits_to_chips_mapper_0, '0', virtual_sink_1, '0']
- [ieee_802_15_4_python_chips_to_bits_mapper_1, '0', blocks_unpacked_to_packed_xx_0, '0']
- [ieee_802_15_4_python_csma_ca_0, mpduout, ieee_802_15_4_python_phy_frame_pack_0, mpdu_in]
- [ieee_802_15_4_python_mac_frame_pack_0, mpduout, ieee_802_15_4_python_csma_ca_0, mpduin]
- [ieee_802_15_4_python_mac_frame_unpack_0, '0', blocks_null_sink_0, '0']
- [ieee_802_15_4_python_mac_frame_unpack_0, cmdout, virtual_sink_1_1_0, '0']
- [ieee_802_15_4_python_phy_frame_pack_0, ppdu_out, ieee_802_15_4_python_bits_to_chips_mapper_0, ppdu_in]
- [ieee_802_15_4_python_phy_frame_unpack_0, mpdu, ieee_802_15_4_python_mac_frame_unpack_0, mpduin]
- [logpwrfft_x_0, '0', virtual_sink_4, '0']
- [virtual_source_0, '0', ieee_802_15_4_python_chips_to_bits_mapper_1, '0']
- [virtual_source_0_1_0, '0', ieee_802_15_4_python_mac_frame_pack_0, cmdin]
- [virtual_source_1, '0', virtual_sink_3, '0']
- [virtual_source_3, '0', ieee_802_15_4_python_csma_ca_0, '0']

metadata:
  file_format: 1

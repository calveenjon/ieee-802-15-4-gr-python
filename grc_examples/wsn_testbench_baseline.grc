options:
  parameters:
    author: Calveen Jon Elvin
    generate_options: qt_gui
    id: wsn_testbench_baseline
    output_language: python
    title: WSN Test Bench Baseline
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: ieee_802_15_4_python_bits_to_chips_mapper_0
  id: ieee_802_15_4_python_bits_to_chips_mapper
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_chips_to_bits_mapper_0
  id: ieee_802_15_4_python_chips_to_bits_mapper
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_mac_frame_pack_0
  id: ieee_802_15_4_python_mac_frame_pack
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_mac_frame_unpack_0
  id: ieee_802_15_4_python_mac_frame_unpack
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_phy_frame_pack_0
  id: ieee_802_15_4_python_phy_frame_pack
  parameters: {}
  states: {}
- name: ieee_802_15_4_python_phy_frame_unpack_0
  id: ieee_802_15_4_python_phy_frame_unpack
  parameters: {}
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: wsn_out
  states: {}
- name: virtual_sink_1_1_0
  id: virtual_sink
  parameters:
    stream_id: mac_cmd
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: wsn_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: wsn_in
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: mac_cmd
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: wsn_out
  states: {}

connections:
- [analog_random_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0_0, '0', ieee_802_15_4_python_mac_frame_pack_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', ieee_802_15_4_python_phy_frame_unpack_0, '0']
- [ieee_802_15_4_python_bits_to_chips_mapper_0, '0', virtual_sink_1, '0']
- [ieee_802_15_4_python_chips_to_bits_mapper_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [ieee_802_15_4_python_mac_frame_pack_0, mpduout, ieee_802_15_4_python_phy_frame_pack_0, mpdu_in]
- [ieee_802_15_4_python_mac_frame_unpack_0, '0', blocks_null_sink_0, '0']
- [ieee_802_15_4_python_mac_frame_unpack_0, cmdout, virtual_sink_1_1_0, '0']
- [ieee_802_15_4_python_phy_frame_pack_0, ppdu_out, ieee_802_15_4_python_bits_to_chips_mapper_0, ppdu_in]
- [ieee_802_15_4_python_phy_frame_unpack_0, mpdu, ieee_802_15_4_python_mac_frame_unpack_0, mpduin]
- [virtual_source_0, '0', ieee_802_15_4_python_chips_to_bits_mapper_0, '0']
- [virtual_source_0_1_0_0, '0', ieee_802_15_4_python_mac_frame_pack_0, cmdin]
- [virtual_source_1, '0', virtual_sink_3, '0']

metadata:
  file_format: 1
